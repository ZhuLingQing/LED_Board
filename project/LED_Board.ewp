# IAR project LED_Board.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: SYSTEM_CLOCK=36000000; USE_STDPERIPH_DRIVER; STM32F10X_MD; _DEBUG
  ICCARM.PreInclude: ..\include\includes.h
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\include; ..\source\applications; ..\source\drivers; ..\source\libraries; ..\source\libraries\cmsis; ..\source\peripherals\inc; ..\source\utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\include
  OBJCOPY.OOCOutputFile: DP_NVMe.bin
  ILINK.IlinkOutputFile: DP_NVMe.hex
  ILINK.IlinkIcfFile: ..\resource\stm32f103RC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  ICCARM.CCDefines: TRACE_LEVEL=TRACE_LEVEL_DEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD; DP_FREERTOS; IAP_BOOT; _NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\include; ..\source\applications; ..\source\drivers; ..\source\libraries; ..\source\libraries\cmsis; ..\source\peripherals\inc; ..\source\utilities; ..\source\freertos\source\include; ..\source\freertos\source\portable\iar\arm_cm3
  prebuild: PreBuild.bat
  postbuild: PostBuild.bat
  ILINK.IlinkOutputFile: DP_NVMe.out
  group Applications
    ../source/Applications/: CommApp.c initialize.c main.c system.c system.h
  group Drivers
    ../source/Drivers/: Button.c Button.h CAN.c CAN.h LED.c LED.h RS232.c RS232.h Ticker.c Ticker.h
  group Includes
    ../include/: board.h buildno.h fsl_common.h includes.h stm32f10x_conf.h stm32f10x_it.h typedef.h version.h
  group Libraries/CMSIS
    ../source/Libraries/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries/startup
    ../source/Libraries/StartUp/: startup_stm32f10x_hd.s startup_stm32f10x_hd_freertos.s
  group Peripherals/inc
    ../source/Peripherals/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Peripherals/src
    ../source/Peripherals/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group resources
    ./: buildno.txt
    ../resource/: STM32F103RC.icf STM32F103x6_boot.icf
  group Utilities
    ../source/Utilities/: crc16.c dbgTrace.c ring_buf.c
    ../source/Utilities/trace/: trace.c
